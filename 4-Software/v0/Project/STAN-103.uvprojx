# Keil uVision project STAN-103.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mercury +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\LED;..\User\USART;..\User\ADC;..\User\PWM;..\User\MPU;..\User\NRF24;..\User\Utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c Filter.c Maths.c
    ../User/utility/: EEPROM.c
    ../User/Utility/: Struct.c Utility.c Task.c Protocol.c Control.c
    ../User/MPU/: IMU.c
  group BSP
    ../User/LED/: bsp_led.c
    ../User/USART/: bsp_usart.c
    ../User/ADC/: bsp_adc.c
    ../User/PWM/: bsp_PWM.c bsp_TIM.c
    ../User/MPU/: bsp_MPU.c
    ../User/NRF24/: bsp_NRF24.c
    ../User/Utility/: bsp_log.c
